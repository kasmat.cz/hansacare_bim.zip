Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-04-25T10:44:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 25 10:44:33 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{F7DBBBB6-5645-4295-9374-42A78B68E420}\ifc * Database version: 5507 * Database creation date: Thu Apr 25 10:44:33 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 25 10:44:33 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 25 10:44:33 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 46012206 Washbasin faucet, 46012206:46012206 Washbasin faucet:342927
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 46012206; ConvergoRefNr: 0087-1905-0029-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 10/04/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 4057304010767; EN Standard: EN 817; Noise Class: I (ISO 3822)
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/46012206; Catalog Drawing URL: http://static.hansa.com/catdrw/46012206; Class: Single lever; Dimension Drawing URL: http://static.hansa.com/dimdrw/46012206; FDV Document URL: http://www.hansa.com/datasheet/46012206/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/46012206; Group: Washbasin faucets; Long Marketing: HANSACARE washbasin faucet with pop-up waste. Ergonomic lever offers good usability to all users and situations. Fixed spout with nickel-free water channels. In-built limitation options for water temperature and maximum flow-rate. Flexible connection pipes G3/8".; Manufacturer: Hansa; Market: INT;DEU;AUT;CHE;BEL;NLD;FRA;CZE;SVK;ITA;ESP; Model: 46012206 Washbasin faucet; Name_en: 46012206 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 380 x 180 x 74; Package Weight: 2.0035 kg; Product Code: 46012206; Product Datasheet: http://www.hansa.com/datasheet/46012206/en; Product Family: HANSACARE; Product Image URL: http://static.hansa.com/image/46012206; Product URL: http://static.hansa.com/46012206; Type Name: 46012206 Washbasin faucet; Usage Group: Offices, personnel sanitary facilities;Kindergartens;Schools;Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Aerator: Pressure controlled aerator;CASCADE®; DN Size: DN15; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.hansa.com/manual/46012206; Installation Type: Deck mounted; Lever Handle: Long lever;Easy to use lever; Max. Hot Water Supply: 90 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Spare Parts: http://static.hansa.com/sp/46012206; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 46012206; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 46012206; Name: 46012206 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x168x178 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Comfort Sales Arguments: Quick and easy to clean.
Pset_ManufacturerTypeInformation - ModelReference: 46012206; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 46012206 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0479501 m2; Volume: 0.00147759 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 46012206: 46012206 Washbasin faucet; Family and Type: 46012206: 46012206 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 46012206: 46012206 Washbasin faucet; Type Id: 46012206: 46012206 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
